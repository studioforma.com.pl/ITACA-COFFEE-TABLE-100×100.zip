Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Itaca-Sofa Coffee table 100x100 - ver4.ifc
Time: 2025-11-13T17:00:24
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (7)
Name
 | Itaca-Sofa Coffee table 100x100_5 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 100x100_6 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 100x100_4 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 100x100_3 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 100x100_2 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 100x100_1 - ObjectType: SketchupGroup
 | Itaca-Sofa Coffee table 100x100_0 - ObjectType: SketchupGroup
